/* AES-128 real (cifrado ECB de un buffer de 1 KiB). Codigo C normal, sin
 * ajustar la mezcla de instrucciones: tablas S-box en memoria, XOR/shifts en
 * la ALU, control de rondas. Implementacion compacta estandar (encrypt only).
 * El checksum final evita que el compilador elimine el trabajo. */
#ifndef REPS
#define REPS 2000
#endif

static const unsigned char SBOX[256] = {
0x63,0x7c,0x77,0x7b,0xf2,0x6b,0x6f,0xc5,0x30,0x01,0x67,0x2b,0xfe,0xd7,0xab,0x76,
0xca,0x82,0xc9,0x7d,0xfa,0x59,0x47,0xf0,0xad,0xd4,0xa2,0xaf,0x9c,0xa4,0x72,0xc0,
0xb7,0xfd,0x93,0x26,0x36,0x3f,0xf7,0xcc,0x34,0xa5,0xe5,0xf1,0x71,0xd8,0x31,0x15,
0x04,0xc7,0x23,0xc3,0x18,0x96,0x05,0x9a,0x07,0x12,0x80,0xe2,0xeb,0x27,0xb2,0x75,
0x09,0x83,0x2c,0x1a,0x1b,0x6e,0x5a,0xa0,0x52,0x3b,0xd6,0xb3,0x29,0xe3,0x2f,0x84,
0x53,0xd1,0x00,0xed,0x20,0xfc,0xb1,0x5b,0x6a,0xcb,0xbe,0x39,0x4a,0x4c,0x58,0xcf,
0xd0,0xef,0xaa,0xfb,0x43,0x4d,0x33,0x85,0x45,0xf9,0x02,0x7f,0x50,0x3c,0x9f,0xa8,
0x51,0xa3,0x40,0x8f,0x92,0x9d,0x38,0xf5,0xbc,0xb6,0xda,0x21,0x10,0xff,0xf3,0xd2,
0xcd,0x0c,0x13,0xec,0x5f,0x97,0x44,0x17,0xc4,0xa7,0x7e,0x3d,0x64,0x5d,0x19,0x73,
0x60,0x81,0x4f,0xdc,0x22,0x2a,0x90,0x88,0x46,0xee,0xb8,0x14,0xde,0x5e,0x0b,0xdb,
0xe0,0x32,0x3a,0x0a,0x49,0x06,0x24,0x5c,0xc2,0xd3,0xac,0x62,0x91,0x95,0xe4,0x79,
0xe7,0xc8,0x37,0x6d,0x8d,0xd5,0x4e,0xa9,0x6c,0x56,0xf4,0xea,0x65,0x7a,0xae,0x08,
0xba,0x78,0x25,0x2e,0x1c,0xa6,0xb4,0xc6,0xe8,0xdd,0x74,0x1f,0x4b,0xbd,0x8b,0x8a,
0x70,0x3e,0xb5,0x66,0x48,0x03,0xf6,0x0e,0x61,0x35,0x57,0xb9,0x86,0xc1,0x1d,0x9e,
0xe1,0xf8,0x98,0x11,0x69,0xd9,0x8e,0x94,0x9b,0x1e,0x87,0xe9,0xce,0x55,0x28,0xdf,
0x8c,0xa1,0x89,0x0d,0xbf,0xe6,0x42,0x68,0x41,0x99,0x2d,0x0f,0xb0,0x54,0xbb,0x16};

#define XT(x) (unsigned char)(((x) << 1) ^ (((x) >> 7) * 0x1b))

static unsigned char RK[176];          /* claves de ronda (key schedule) */
static unsigned char BUF[1024];        /* el "mensaje" a cifrar */

static void key_expand(const unsigned char *key) {
  unsigned char rcon = 1;
  for (int i = 0; i < 16; i++) RK[i] = key[i];
  for (int i = 16; i < 176; i += 4) {
    unsigned char t[4] = {RK[i-4], RK[i-3], RK[i-2], RK[i-1]};
    if ((i & 15) == 0) {
      unsigned char tmp = t[0];
      t[0] = (unsigned char)(SBOX[t[1]] ^ rcon);
      t[1] = SBOX[t[2]]; t[2] = SBOX[t[3]]; t[3] = SBOX[tmp];
      rcon = XT(rcon);
    }
    for (int j = 0; j < 4; j++) RK[i+j] = (unsigned char)(RK[i-16+j] ^ t[j]);
  }
}

static void aes_block(unsigned char *s) {
  for (int j = 0; j < 16; j++) s[j] ^= RK[j];
  for (int r = 1; r <= 10; r++) {
    unsigned char t;
    for (int j = 0; j < 16; j++) s[j] = SBOX[s[j]];      /* SubBytes  */
    t = s[1];  s[1]  = s[5];  s[5]  = s[9];  s[9]  = s[13]; s[13] = t;
    t = s[2];  s[2]  = s[10]; s[10] = t;  t = s[6];  s[6]  = s[14]; s[14] = t;
    t = s[15]; s[15] = s[11]; s[11] = s[7]; s[7]  = s[3];  s[3]  = t;
    if (r < 10)                                          /* MixColumns */
      for (int c = 0; c < 16; c += 4) {
        unsigned char a0=s[c],a1=s[c+1],a2=s[c+2],a3=s[c+3];
        unsigned char x = (unsigned char)(a0^a1^a2^a3);
        s[c]   ^= (unsigned char)(XT((unsigned char)(a0^a1)) ^ x);
        s[c+1] ^= (unsigned char)(XT((unsigned char)(a1^a2)) ^ x);
        s[c+2] ^= (unsigned char)(XT((unsigned char)(a2^a3)) ^ x);
        s[c+3] ^= (unsigned char)(XT((unsigned char)(a3^a0)) ^ x);
      }
    for (int j = 0; j < 16; j++) s[j] ^= RK[16*r + j];   /* AddRoundKey */
  }
}

void run_workload(void) {
  static const unsigned char key[16] =
    {0x2b,0x7e,0x15,0x16,0x28,0xae,0xd2,0xa6,0xab,0xf7,0x15,0x88,0x09,0xcf,0x4f,0x3c};
  volatile unsigned sink = 0;
  key_expand(key);
  for (unsigned i = 0; i < sizeof BUF; i++) BUF[i] = (unsigned char)(i * 7 + 13);
  for (int r = 0; r < REPS; r++) {
    for (unsigned b = 0; b < sizeof BUF; b += 16) aes_block(BUF + b);
    sink += BUF[(r * 16u) & 1023];
  }
}
