/* AES-128 ECB: cifrado por bloques (algoritmo real, criptografia).
 * Mezcla natural: ALU (xor, shifts, GF(2^8) mul), MEM (tablas S-box / round
 * keys), CTRL (rondas). Sin float ni division. Basado en el estandar FIPS-197;
 * implementacion compacta autocontenida (sin libc). */
#ifndef REPS
#define REPS 150000
#endif

typedef unsigned char u8;

static const u8 sbox[256] = {
  0x63,0x7c,0x77,0x7b,0xf2,0x6b,0x6f,0xc5,0x30,0x01,0x67,0x2b,0xfe,0xd7,0xab,0x76,
  0xca,0x82,0xc9,0x7d,0xfa,0x59,0x47,0xf0,0xad,0xd4,0xa2,0xaf,0x9c,0xa4,0x72,0xc0,
  0xb7,0xfd,0x93,0x26,0x36,0x3f,0xf7,0xcc,0x34,0xa5,0xe5,0xf1,0x71,0xd8,0x31,0x15,
  0x04,0xc7,0x23,0xc3,0x18,0x96,0x05,0x9a,0x07,0x12,0x80,0xe2,0xeb,0x27,0xb2,0x75,
  0x09,0x83,0x2c,0x1a,0x1b,0x6e,0x5a,0xa0,0x52,0x3b,0xd6,0xb3,0x29,0xe3,0x2f,0x84,
  0x53,0xd1,0x00,0xed,0x20,0xfc,0xb1,0x5b,0x6a,0xcb,0xbe,0x39,0x4a,0x4c,0x58,0xcf,
  0xd0,0xef,0xaa,0xfb,0x43,0x4d,0x33,0x85,0x45,0xf9,0x02,0x7f,0x50,0x3c,0x9f,0xa8,
  0x51,0xa3,0x40,0x8f,0x92,0x9d,0x38,0xf5,0xbc,0xb6,0xda,0x21,0x10,0xff,0xf3,0xd2,
  0xcd,0x0c,0x13,0xec,0x5f,0x97,0x44,0x17,0xc4,0xa7,0x7e,0x3d,0x64,0x5d,0x19,0x73,
  0x60,0x81,0x4f,0xdc,0x22,0x2a,0x90,0x88,0x46,0xee,0xb8,0x14,0xde,0x5e,0x0b,0xdb,
  0xe0,0x32,0x3a,0x0a,0x49,0x06,0x24,0x5c,0xc2,0xd3,0xac,0x62,0x91,0x95,0xe4,0x79,
  0xe7,0xc8,0x37,0x6d,0x8d,0xd5,0x4e,0xa9,0x6c,0x56,0xf4,0xea,0x65,0x7a,0xae,0x08,
  0xba,0x78,0x25,0x2e,0x1c,0xa6,0xb4,0xc6,0xe8,0xdd,0x74,0x1f,0x4b,0xbd,0x8b,0x8a,
  0x70,0x3e,0xb5,0x66,0x48,0x03,0xf6,0x0e,0x61,0x35,0x57,0xb9,0x86,0xc1,0x1d,0x9e,
  0xe1,0xf8,0x98,0x11,0x69,0xd9,0x8e,0x94,0x9b,0x1e,0x87,0xe9,0xce,0x55,0x28,0xdf,
  0x8c,0xa1,0x89,0x0d,0xbf,0xe6,0x42,0x68,0x41,0x99,0x2d,0x0f,0xb0,0x54,0xbb,0x16
};
static const u8 Rcon[11] = {0x00,0x01,0x02,0x04,0x08,0x10,0x20,0x40,0x80,0x1b,0x36};

static u8 rk[176];   /* 11 round keys x 16 bytes */

static void KeyExpansion(const u8 *key){
  for(int i=0;i<16;i++) rk[i]=key[i];
  for(int i=16;i<176;i+=4){
    u8 t0=rk[i-4],t1=rk[i-3],t2=rk[i-2],t3=rk[i-1];
    if((i & 15)==0){
      u8 tmp=t0;                    /* RotWord + SubWord + Rcon */
      t0=sbox[t1]^Rcon[i/16];
      t1=sbox[t2]; t2=sbox[t3]; t3=sbox[tmp];
    }
    rk[i]  =rk[i-16]^t0;
    rk[i+1]=rk[i-15]^t1;
    rk[i+2]=rk[i-14]^t2;
    rk[i+3]=rk[i-13]^t3;
  }
}

static u8 xtime(u8 x){ return (u8)((x<<1) ^ (((x>>7)&1)*0x1b)); }

static void shiftrows(u8 *s){
  u8 t;
  t=s[1];  s[1]=s[5];  s[5]=s[9];  s[9]=s[13]; s[13]=t;
  t=s[2];  s[2]=s[10]; s[10]=t;    t=s[6];     s[6]=s[14]; s[14]=t;
  t=s[15]; s[15]=s[11];s[11]=s[7]; s[7]=s[3];  s[3]=t;
}

static void Cipher(u8 *s){
  for(int c=0;c<16;c++) s[c]^=rk[c];          /* AddRoundKey 0 */
  for(int r=1;r<10;r++){
    for(int c=0;c<16;c++) s[c]=sbox[s[c]];     /* SubBytes */
    shiftrows(s);                              /* ShiftRows */
    for(int c=0;c<16;c+=4){                     /* MixColumns */
      u8 a0=s[c],a1=s[c+1],a2=s[c+2],a3=s[c+3];
      u8 h=a0^a1^a2^a3;
      s[c]  ^= h ^ xtime(a0^a1);
      s[c+1]^= h ^ xtime(a1^a2);
      s[c+2]^= h ^ xtime(a2^a3);
      s[c+3]^= h ^ xtime(a3^a0);
    }
    for(int c=0;c<16;c++) s[c]^=rk[r*16+c];    /* AddRoundKey r */
  }
  for(int c=0;c<16;c++) s[c]=sbox[s[c]];        /* ronda final */
  shiftrows(s);
  for(int c=0;c<16;c++) s[c]^=rk[160+c];
}

void run_workload(void){
  static u8 key[16]={0x2b,0x7e,0x15,0x16,0x28,0xae,0xd2,0xa6,
                     0xab,0xf7,0x15,0x88,0x09,0xcf,0x4f,0x3c};
  static u8 state[16]={0x32,0x43,0xf6,0xa8,0x88,0x5a,0x30,0x8d,
                       0x31,0x31,0x98,0xa2,0xe0,0x37,0x07,0x34};
  KeyExpansion(key);
  for(int r=0;r<REPS;r++){
    Cipher(state);
    state[0]^=(u8)r;        /* encadena: la salida realimenta la entrada */
  }
  volatile u8 sink=0;
  for(int i=0;i<16;i++) sink^=state[i];
  (void)sink;
}
